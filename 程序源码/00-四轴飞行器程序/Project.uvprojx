# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Start;.\Library;.\User;.\System;.\Hardware;.\Module
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: Delay.c Delay.h Timer.h Timer.c MyFLASH.c MyFLASH.h Store.c Store.h
  group Hardware
    ./Hardware/: LED.c LED.h OLED.c OLED.h OLED_Data.c OLED_Data.h Key.c Key.h PWM.c PWM.h AD.c AD.h NRF24L01.c NRF24L01.h NRF24L01_Define.h Serial.c Serial.h MyI2C.c MyI2C.h QMI8658.c QMI8658.h QMI8658_Reg.h QMC6309.c QMC6309.h QMC6309_Reg.h SPA06.c SPA06.h SPA06_Reg.h
  group Module
    ./Module/: MyI2C2.c MyI2C2.h vl53l1_platform.c vl53l1_platform.h vl53l1_types.h VL53L1X_api.c VL53L1X_api.h VL53L1X_calibration.c VL53L1X_calibration.h VL53L1X.c VL53L1X.h MySPI.c MySPI.h PAA3905.c PAA3905.h PAA3905_Reg.h PMW3901.c PMW3901.h PMW3901_Reg.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h IMU.c IMU.h PID.c PID.h Utils.c Utils.h DebugMode.c DebugMode.h Menu.c Menu.h
